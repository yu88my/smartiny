# Keil uVision project Sys_Template.uvproj, settings and files
target FLASH (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Sys_Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport;..\StdPeriph_Driver\inc;..\User\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/src/: main.c stm32f10x_it.c LED.c KEY.c UART.c System_conf.c STM32_RTC.c
  group StdPeriph_Driver
    ../StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group StartUp
    ../Startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/CoreSupport/: core_cm3.c
    ../CMSIS/DeviceSupport/: system_stm32f10x.c
  group Read Me
    ../Read Me/: Read Me.c
